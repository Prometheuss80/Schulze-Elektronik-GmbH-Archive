# Keil uVision project XTOOLS_ISL8_SERVICE.uvproj, settings and files
target Target 1 (MCS-51)
  device: SAB 80C537 Infineon
  cpu: IRAM(0-0xFF) CLOCK(16000000) MOD517DP MOD517AU
  output: XTOOLS_ISL8_SERVICE +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: gui.h adc.h battery_protection.h config.h eeprom_fixed_test.h hardware.h charge.h internalfan.h keyboard.h lcd.h lcd_bitmap.h lcd_font.h measurement.h REG80C537_ISL8.h serial.h service.h sound.h system.h test5v.h timekeeper.h watchdog.h wdt_2edge_test.h gui.c main.c adc.c battery_protection.c eeprom.c hardware.c charge.c internalfan.c keyboard.c lcd.c lcd_bitmap.c lcd_font.c measurement.c serial.c service.c sound.c system.c test5v.c timekeeper.c watchdog.c eeprom_asm.a51 STARTUP.A51 watchdog_asm.a51 lcd_hw.h
