$NOMOD51
IDATALEN EQU 80H
ACC DATA 0E0H
B DATA 0F0H
SP DATA 81H
DPL DATA 82H
DPH DATA 83H
NAME ?C_STARTUP
?C_C51STARTUP SEGMENT CODE
?STACK SEGMENT IDATA
RSEG ?STACK
DS 1
EXTRN CODE (?C_START)
PUBLIC ?C_STARTUP
CSEG AT 0
?C_STARTUP: LJMP STARTUP1
RSEG ?C_C51STARTUP
STARTUP1:
 MOV R0,#IDATALEN-1
 CLR A
IDATALOOP: MOV @R0,A
 DJNZ R0,IDATALOOP
 MOV SP,#?STACK-1
 LJMP ?C_START
END
